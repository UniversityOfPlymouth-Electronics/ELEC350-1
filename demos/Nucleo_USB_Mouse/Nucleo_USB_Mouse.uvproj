# Keil uVision project Nucleo_USB_Mouse.uvproj, settings and files
target Nucleo_USB_Mouse (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Nucleo_USB_Mouse
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1
  c define: TARGET_RTOS_M4_M7, TARGET_FF_ARDUINO, __CORTEX_M4, TARGET_STM32F401RE, TARGET_FF_MORPHO, __FPU_PRESENT=1, TARGET_CORTEX_M, TOOLCHAIN_ARM_MICRO, TARGET_LIKE_CORTEX_M4, TARGET_NUCLEO_F401RE, TARGET_M4, __MBED__=1, TARGET_STM, TARGET_LIKE_MBED, TARGET_STM32F4, TOOLCHAIN_ARM, ARM_MATH_CM4, MBED_BUILD_TIMESTAMP=1468920025, __ASSERT_MSG
  c misc: --gnu --no_rtti --restrict --apcs=interwork -c -O3 -I"C:/Program Files/ARM/armcc_4.1_791/include" --split_sections --multibyte_chars --brief_diagnostics --library_type=microlib --cpu=Cortex-M4.fp -D__ASSERT_MSG --no_depend_system_headers --md -Otime --gnu --brief_diagnostics --library_type=microlib --cpu=Cortex-M4.fp --apcs=interwork
  c include: .; USBDevice; USBDevice/USBHID; USBDevice/USBDevice; USBDevice/USBAudio; USBDevice/USBSerial; USBDevice/USBMSD; USBDevice/USBMIDI; mbed; mbed/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TARGET_STM; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO
  asm define: as above
  asm misc: --brief_diagnostics --cpu=Cortex-M4.fp --apcs=interwork -I"C:/Program Files/ARM/armcc_4.1_791/include"
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO/stm32f401xe.sct
  link misc: --library_type=microlib
  group Include Files
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    USBDevice/USBSerial/: CircBuffer.h USBCDC.h USBSerial.h
    mbed/TARGET_NUCLEO_F401RE/: cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h hal_tick.h stm32_hal_legacy.h stm32f401xe.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/: gpio_object.h PeripheralPins.h
    USBDevice/USBMIDI/: MIDIMessage.h USBMIDI.h
    USBDevice/USBAudio/: USBAudio.h USBAudio_Types.h
    USBDevice/USBDevice/: USBDescriptor.h USBDevice.h USBDevice_Types.h USBEndpoints.h USBEndpoints_KL25Z.h USBEndpoints_LPC11U.h USBEndpoints_LPC17_LPC23.h USBEndpoints_STM32F4.h USBHAL.h USBRegs_STM32.h
    USBDevice/USBHID/: USBHID.h USBHID_Types.h USBKeyboard.h USBMouse.h USBMouseKeyboard.h
    USBDevice/USBMSD/: USBMSD.h
  group Source Files
    ./: main.cpp
    mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_stm32f401xe.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o sys.o system_stm32f4xx.o
    USBDevice/USBAudio/: USBAudio.cpp
    USBDevice/USBSerial/: USBCDC.cpp USBSerial.cpp
    USBDevice/USBDevice/: USBDevice.cpp USBHAL_KL25Z.cpp USBHAL_LPC11U.cpp USBHAL_LPC17.cpp USBHAL_LPC40.cpp USBHAL_STM32F4.cpp
    USBDevice/USBHID/: USBHID.cpp USBKeyboard.cpp USBMouse.cpp USBMouseKeyboard.cpp
    USBDevice/USBMIDI/: USBMIDI.cpp
    USBDevice/USBMSD/: USBMSD.cpp
